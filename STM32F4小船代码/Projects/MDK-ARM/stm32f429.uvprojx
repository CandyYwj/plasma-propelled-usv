# Keil uVision project stm32f429.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\BSP\led;..\..\Drivers\BSP\uart1;..\..\Drivers\BSP\uart2;..\..\Drivers\BSP\uart6;..\..\Drivers\BSP\ds18b20;..\..\Drivers\BSP\tds;..\..\Drivers\BSP\uart3;..\..\Drivers\BSP\ultrasonic;..\..\Drivers\BSP\laser;..\..\Drivers\BSP\filtering;..\..\Drivers\BSP\wit_c_sdk;..\..\Drivers\BSP\iic;..\..\Drivers\BSP\IMU;..\..\Drivers\BSP\GPS;..\..\Drivers\BSP\uart8;..\..\Drivers\BSP\TIM;..\..\Drivers\BSP\pid;..\..\Drivers\BSP\navigation
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group User
    ../../Users/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32Fxx_HAL_Drivers
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_usart.c stm32f4xx_ll_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_gpio.c stm32f4xx_hal_timebase_tim_template.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c
  group Drivers
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/uart1/: uart1.c
    ../../Drivers/BSP/uart2/: uart2.c
    ../../Drivers/BSP/uart6/: uart6.c
    ../../Drivers/BSP/ds18b20/: ds18b20.c
    ../../Drivers/BSP/tds/: tds.c
    ../../Drivers/BSP/uart3/: uart3.c
    ../../Drivers/BSP/ultrasonic/: ultrasonic.c
    ../../Drivers/BSP/laser/: laser.c
    ../../Drivers/BSP/filtering/: filtering.c
    ../../Drivers/BSP/iic/: IOI2C.c
    ../../Drivers/BSP/wit_c_sdk/: wit_c_sdk.c
    ../../Drivers/BSP/IMU/: IMU.c
    ../../Drivers/BSP/GPS/: gps.c
    ../../Drivers/BSP/uart8/: uart8.c
    ../../Drivers/BSP/TIM/: tim.c
    ../../Drivers/BSP/pid/: pid.c
    ../../Drivers/BSP/navigation/: navigation.c
